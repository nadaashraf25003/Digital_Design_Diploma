

# LEF File for Accumulated Process Antenna Effects at the Boundary Pins
# *********************************************************************

VERSION 5.5 ;
DIVIDERCHAR "/" ;
BUSBITCHARS "[]" ;

MACRO ALU_TOP 
  PIN scan_clk 
    ANTENNAPARTIALMETALAREA 0.974 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.87734 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 0.796 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 4.02116 LAYER METAL4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2002 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 7.4001 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 38.0526 LAYER METAL4 ;
    ANTENNAMAXCUTCAR 0.721279 LAYER VIA45 ;
  END scan_clk
  PIN scan_rst 
    ANTENNAPARTIALMETALAREA 0.975 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.68975 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1547 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 8.57062 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 40.5824 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 0.700065 LAYER VIA34 ;
  END scan_rst
  PIN test_mode 
    ANTENNAPARTIALMETALAREA 0.811 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.90091 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.5148 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 5.7849 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 27.1323 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 0.298028 LAYER VIA34 ;
  END test_mode
  PIN SI 
    ANTENNAPARTIALMETALAREA 5.035 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 24.2184 LAYER METAL2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0533 LAYER METAL2 ; 
    ANTENNAMAXAREACAR 97.0854 LAYER METAL2 ;
    ANTENNAMAXSIDEAREACAR 466.329 LAYER METAL2 ;
    ANTENNAMAXCUTCAR 0.677298 LAYER VIA23 ;
  END SI
  PIN SE 
    ANTENNAPARTIALMETALAREA 19.186 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 94.0162 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 3.0082 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 38.6655 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 187.044 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAMAXCUTCAR 1.58407 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 8.882 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 43.1072 LAYER METAL4 ;
    ANTENNAGATEAREA 4.5123 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 40.6339 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 196.598 LAYER METAL4 ;
    ANTENNAMAXCUTCAR 1.97609 LAYER VIA45 ;
  END SE
  PIN SO 
    ANTENNAPARTIALMETALAREA 2.72 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 13.0832 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNADIFFAREA 0.333 LAYER METAL4 ; 
    ANTENNAPARTIALMETALAREA 14.923 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 71.972 LAYER METAL4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0897 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 221.497 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 1069.59 LAYER METAL4 ;
    ANTENNAMAXCUTCAR 2.01226 LAYER VIA45 ;
  END SO
  PIN A[7] 
    ANTENNAPARTIALMETALAREA 4.816 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 23.7422 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4498 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 17.0718 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 83.5838 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA34 ;
    ANTENNAMAXCUTCAR 0.957181 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 0.96 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 4.81 LAYER METAL4 ;
    ANTENNAGATEAREA 0.4498 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 19.206 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 94.2775 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA45 ;
    ANTENNAMAXCUTCAR 1.1177 LAYER VIA45 ;
    ANTENNAPARTIALMETALAREA 5.762 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 27.9076 LAYER METAL5 ;
    ANTENNAGATEAREA 1.6107 LAYER METAL5 ; 
    ANTENNAMAXAREACAR 65.4638 LAYER METAL5 ;
    ANTENNAMAXSIDEAREACAR 316.114 LAYER METAL5 ;
    ANTENNAMAXCUTCAR 1.81081 LAYER VIA56 ;
  END A[7]
  PIN A[6] 
    ANTENNAPARTIALMETALAREA 6.117 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 29.8076 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4498 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 25.457 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 123.656 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA34 ;
    ANTENNAMAXCUTCAR 1.8378 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 4.26 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 21.2602 LAYER METAL4 ;
    ANTENNAGATEAREA 2.3972 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 27.8907 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 135.814 LAYER METAL4 ;
    ANTENNAMAXCUTCAR 1.8378 LAYER VIA45 ;
  END A[6]
  PIN A[5] 
    ANTENNAPARTIALMETALAREA 13.453 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 65.2861 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.1206 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 29.1797 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 141.055 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAMAXCUTCAR 1.52597 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 7.542 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 36.6618 LAYER METAL4 ;
    ANTENNAGATEAREA 1.9942 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 32.9616 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 159.439 LAYER METAL4 ;
    ANTENNAMAXCUTCAR 2.19878 LAYER VIA45 ;
  END A[5]
  PIN A[4] 
    ANTENNAPARTIALMETALAREA 6.327 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 30.4329 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.208 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 31.7046 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 153.285 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAMAXCUTCAR 0.694231 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 0.423 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 2.22703 LAYER METAL4 ;
    ANTENNAGATEAREA 0.208 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 33.7382 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 163.992 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA45 ;
    ANTENNAMAXCUTCAR 1.04135 LAYER VIA45 ;
    ANTENNAPARTIALMETALAREA 6.45 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 31.2169 LAYER METAL5 ;
    ANTENNAGATEAREA 1.9942 LAYER METAL5 ; 
    ANTENNAMAXAREACAR 36.9726 LAYER METAL5 ;
    ANTENNAMAXSIDEAREACAR 179.646 LAYER METAL5 ;
    ANTENNAMAXCUTCAR 1.18304 LAYER VIA56 ;
  END A[4]
  PIN A[3] 
    ANTENNAPARTIALMETALAREA 5.518 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 26.9264 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.208 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 32.3921 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 158.442 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAMAXCUTCAR 1.56202 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 11.774 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 57.0177 LAYER METAL4 ;
    ANTENNAGATEAREA 1.1128 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 42.9726 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 209.68 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.1083 LAYER VIA45 ;
    ANTENNAMAXCUTCAR 1.65934 LAYER VIA45 ;
    ANTENNAPARTIALMETALAREA 9.182 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 44.5502 LAYER METAL5 ;
    ANTENNAGATEAREA 2.1788 LAYER METAL5 ; 
    ANTENNAMAXAREACAR 47.1868 LAYER METAL5 ;
    ANTENNAMAXSIDEAREACAR 230.127 LAYER METAL5 ;
    ANTENNAMAXCUTCAR 1.65934 LAYER VIA56 ;
  END A[3]
  PIN A[2] 
    ANTENNAPARTIALMETALAREA 0.296 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.42376 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 10.741 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 52.8186 LAYER METAL4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 2.0254 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 50.4236 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 244.791 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA45 ;
    ANTENNAMAXCUTCAR 1.45244 LAYER VIA45 ;
    ANTENNAPARTIALMETALAREA 8.459 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 40.8802 LAYER METAL5 ;
    ANTENNAGATEAREA 2.1788 LAYER METAL5 ; 
    ANTENNAMAXAREACAR 54.306 LAYER METAL5 ;
    ANTENNAMAXSIDEAREACAR 263.554 LAYER METAL5 ;
    ANTENNAMAXCUTCAR 1.45244 LAYER VIA56 ;
  END A[2]
  PIN A[1] 
    ANTENNAPARTIALMETALAREA 12.246 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 60.0577 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.8148 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 49.5725 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 239.264 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAMAXCUTCAR 1.23416 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 1.147 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 5.70947 LAYER METAL4 ;
    ANTENNAGATEAREA 1.8148 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 50.2045 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 242.41 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA45 ;
    ANTENNAMAXCUTCAR 1.27394 LAYER VIA45 ;
    ANTENNAPARTIALMETALAREA 6.008 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 29.0909 LAYER METAL5 ;
    ANTENNAGATEAREA 2.223 LAYER METAL5 ; 
    ANTENNAMAXAREACAR 57.4256 LAYER METAL5 ;
    ANTENNAMAXSIDEAREACAR 277.362 LAYER METAL5 ;
    ANTENNAMAXCUTCAR 1.45199 LAYER VIA56 ;
  END A[1]
  PIN A[0] 
    ANTENNAPARTIALMETALAREA 11.456 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 56.2578 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.6773 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 35.8911 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 174.969 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.1444 LAYER VIA34 ;
    ANTENNAMAXCUTCAR 1.33898 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 7.014 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 34.1221 LAYER METAL4 ;
    ANTENNAGATEAREA 1.2155 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 41.6615 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 203.041 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.1444 LAYER VIA45 ;
    ANTENNAMAXCUTCAR 1.45778 LAYER VIA45 ;
    ANTENNAPARTIALMETALAREA 9.228 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 44.7715 LAYER METAL5 ;
    ANTENNAGATEAREA 1.8226 LAYER METAL5 ; 
    ANTENNAMAXAREACAR 46.7246 LAYER METAL5 ;
    ANTENNAMAXSIDEAREACAR 227.606 LAYER METAL5 ;
    ANTENNAMAXCUTCAR 1.45778 LAYER VIA56 ;
  END A[0]
  PIN B[7] 
    ANTENNAPARTIALMETALAREA 1.239 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 5.95959 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 12.448 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 60.4521 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.9828 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 32.5847 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 157.535 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAMAXCUTCAR 1.30375 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 14.741 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 71.0966 LAYER METAL4 ;
    ANTENNAGATEAREA 1.6744 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 41.3884 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 199.996 LAYER METAL4 ;
    ANTENNAMAXCUTCAR 1.30375 LAYER VIA45 ;
  END B[7]
  PIN B[6] 
    ANTENNAPARTIALMETALAREA 4.772 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 22.9533 LAYER METAL2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2054 LAYER METAL2 ; 
    ANTENNAMAXAREACAR 24.0112 LAYER METAL2 ;
    ANTENNAMAXSIDEAREACAR 114.585 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA23 ;
    ANTENNAMAXCUTCAR 0.527264 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 3.092 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 15.0649 LAYER METAL3 ;
    ANTENNAGATEAREA 0.2054 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 39.0648 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 187.929 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA34 ;
    ANTENNAMAXCUTCAR 0.703018 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 7.496 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 36.4406 LAYER METAL4 ;
    ANTENNAGATEAREA 2.1008 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 42.6329 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 205.275 LAYER METAL4 ;
    ANTENNAMAXCUTCAR 1.02939 LAYER VIA45 ;
  END B[6]
  PIN B[5] 
    ANTENNAPARTIALMETALAREA 1.371 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 6.59451 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 8.122 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 39.2592 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.3328 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 26.8725 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 130.008 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.2166 LAYER VIA34 ;
    ANTENNAMAXCUTCAR 1.21756 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 14.258 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 69.543 LAYER METAL4 ;
    ANTENNAGATEAREA 1.1284 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 43.2427 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 210.455 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.1444 LAYER VIA45 ;
    ANTENNAMAXCUTCAR 2.24372 LAYER VIA45 ;
    ANTENNAPARTIALMETALAREA 12.991 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 62.8715 LAYER METAL5 ;
    ANTENNAGATEAREA 1.4872 LAYER METAL5 ; 
    ANTENNAMAXAREACAR 51.9779 LAYER METAL5 ;
    ANTENNAMAXSIDEAREACAR 252.731 LAYER METAL5 ;
    ANTENNAMAXCUTCAR 2.24372 LAYER VIA56 ;
  END B[5]
  PIN B[4] 
    ANTENNAPARTIALMETALAREA 2.854 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 13.7277 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 16.602 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 80.4328 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4888 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 53.3961 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 260.642 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.1444 LAYER VIA34 ;
    ANTENNAMAXCUTCAR 3.60128 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 9.264 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 44.9446 LAYER METAL4 ;
    ANTENNAGATEAREA 1.027 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 62.4166 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 304.405 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA45 ;
    ANTENNAMAXCUTCAR 3.63643 LAYER VIA45 ;
    ANTENNAPARTIALMETALAREA 9.388 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 45.3487 LAYER METAL5 ;
    ANTENNAGATEAREA 1.4872 LAYER METAL5 ; 
    ANTENNAMAXAREACAR 68.7291 LAYER METAL5 ;
    ANTENNAMAXSIDEAREACAR 334.898 LAYER METAL5 ;
    ANTENNAMAXCUTCAR 3.63643 LAYER VIA56 ;
  END B[4]
  PIN B[3] 
    ANTENNAPARTIALMETALAREA 0.506 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 2.43386 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 6.122 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 29.6392 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.3328 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 21.6478 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 104.878 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAMAXCUTCAR 0.783666 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 1.871 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 9.19191 LAYER METAL4 ;
    ANTENNAGATEAREA 0.3328 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 27.2698 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 132.497 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA45 ;
    ANTENNAMAXCUTCAR 0.89214 LAYER VIA45 ;
    ANTENNAPARTIALMETALAREA 10.953 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 53.2611 LAYER METAL5 ;
    ANTENNAGATEAREA 1.5106 LAYER METAL5 ; 
    ANTENNAMAXAREACAR 48.3641 LAYER METAL5 ;
    ANTENNAMAXSIDEAREACAR 234.999 LAYER METAL5 ;
    ANTENNAMAXCUTCAR 1.59367 LAYER VIA56 ;
  END B[3]
  PIN B[2] 
    ANTENNAPARTIALMETALAREA 0.253 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 1.21693 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 6.042 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 29.6392 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.3328 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 43.1692 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 209.406 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA34 ;
    ANTENNAMAXCUTCAR 0.987247 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 6.362 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 30.986 LAYER METAL4 ;
    ANTENNAGATEAREA 0.897 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 50.2617 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 243.95 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA45 ;
    ANTENNAMAXCUTCAR 1.06774 LAYER VIA45 ;
    ANTENNAPARTIALMETALAREA 12.755 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 61.544 LAYER METAL5 ;
    ANTENNAGATEAREA 1.5106 LAYER METAL5 ; 
    ANTENNAMAXAREACAR 58.7054 LAYER METAL5 ;
    ANTENNAMAXSIDEAREACAR 284.691 LAYER METAL5 ;
    ANTENNAMAXCUTCAR 1.31031 LAYER VIA56 ;
  END B[2]
  PIN B[1] 
    ANTENNAPARTIALMETALAREA 4.441 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 21.5536 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.3328 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 21.8195 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 104.511 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAMAXCUTCAR 0.919966 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 6.149 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 29.7691 LAYER METAL4 ;
    ANTENNAGATEAREA 1.4924 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 47.4651 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 230.046 LAYER METAL4 ;
    ANTENNAMAXCUTCAR 1.84217 LAYER VIA45 ;
  END B[1]
  PIN B[0] 
    ANTENNAPARTIALMETALAREA 1.023 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.92063 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 10.193 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 49.6055 LAYER METAL4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.6929 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 31.2291 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 152.01 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA45 ;
    ANTENNAMAXCUTCAR 1.51024 LAYER VIA45 ;
    ANTENNAPARTIALMETALAREA 5.27 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 25.5411 LAYER METAL5 ;
    ANTENNAGATEAREA 1.9227 LAYER METAL5 ; 
    ANTENNAMAXAREACAR 33.9701 LAYER METAL5 ;
    ANTENNAMAXSIDEAREACAR 165.294 LAYER METAL5 ;
    ANTENNAMAXCUTCAR 1.51024 LAYER VIA56 ;
  END B[0]
  PIN ALU_FUNC[3] 
    ANTENNAPARTIALMETALAREA 3.709 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 17.8403 LAYER METAL2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2054 LAYER METAL2 ; 
    ANTENNAMAXAREACAR 18.8784 LAYER METAL2 ;
    ANTENNAMAXSIDEAREACAR 89.7981 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA23 ;
    ANTENNAMAXCUTCAR 0.527264 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 5.985 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 28.9803 LAYER METAL3 ;
    ANTENNAGATEAREA 0.6162 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 28.5912 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 136.829 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 0.527264 LAYER VIA34 ;
  END ALU_FUNC[3]
  PIN ALU_FUNC[2] 
    ANTENNAPARTIALMETALAREA 3.821 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 18.379 LAYER METAL2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2054 LAYER METAL2 ; 
    ANTENNAMAXAREACAR 22.1793 LAYER METAL2 ;
    ANTENNAMAXSIDEAREACAR 104.542 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA23 ;
    ANTENNAMAXCUTCAR 0.703018 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 6.327 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 30.6253 LAYER METAL3 ;
    ANTENNAGATEAREA 0.6162 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 32.4471 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 154.243 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 0.703018 LAYER VIA34 ;
  END ALU_FUNC[2]
  PIN ALU_FUNC[1] 
    ANTENNAPARTIALMETALAREA 1.436 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 6.90716 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 11.336 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 55.1034 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.157 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 23.7895 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 114.954 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAMAXCUTCAR 1.18213 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 7.074 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 34.2183 LAYER METAL4 ;
    ANTENNAGATEAREA 2.2542 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 26.9276 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 130.134 LAYER METAL4 ;
    ANTENNAMAXCUTCAR 1.18213 LAYER VIA45 ;
  END ALU_FUNC[1]
  PIN ALU_FUNC[0] 
    ANTENNAPARTIALMETALAREA 2.595 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 12.482 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 0.245 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.37085 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 0.268 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 1.48148 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA45 ;
    ANTENNAPARTIALMETALAREA 8.632 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 41.7123 LAYER METAL5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 2.0436 LAYER METAL5 ; 
    ANTENNAMAXAREACAR 35.6212 LAYER METAL5 ;
    ANTENNAMAXSIDEAREACAR 169.253 LAYER METAL5 ;
    ANTENNAMAXCUTCAR 1.65373 LAYER VIA56 ;
  END ALU_FUNC[0]
  PIN CLK 
    ANTENNAPARTIALMETALAREA 1.267 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 6.09427 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 3.0628 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 0.548714 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 2.65942 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 0.0235732 LAYER VIA34 ;
  END CLK
  PIN RST 
    ANTENNAPARTIALMETALAREA 1.525 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 7.52765 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1534 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 21.6411 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 105.15 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 0.705997 LAYER VIA34 ;
  END RST
  PIN Arith_OUT[15] 
    ANTENNADIFFAREA 4.543 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 2.772 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 13.3333 LAYER METAL3 ;
  END Arith_OUT[15]
  PIN Arith_OUT[14] 
    ANTENNADIFFAREA 4.543 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 0.257 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.23617 LAYER METAL3 ;
  END Arith_OUT[14]
  PIN Arith_OUT[13] 
    ANTENNADIFFAREA 4.543 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 1.473 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 7.08513 LAYER METAL3 ;
  END Arith_OUT[13]
  PIN Arith_OUT[12] 
    ANTENNADIFFAREA 4.543 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 1.361 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 6.54641 LAYER METAL3 ;
  END Arith_OUT[12]
  PIN Arith_OUT[11] 
    ANTENNADIFFAREA 4.543 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 1.911 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 9.19191 LAYER METAL3 ;
  END Arith_OUT[11]
  PIN Arith_OUT[10] 
    ANTENNADIFFAREA 4.543 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 1.352 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 6.50312 LAYER METAL3 ;
  END Arith_OUT[10]
  PIN Arith_OUT[9] 
    ANTENNADIFFAREA 4.543 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 2.73 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 13.1313 LAYER METAL3 ;
  END Arith_OUT[9]
  PIN Arith_OUT[8] 
    ANTENNADIFFAREA 4.543 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 1.394 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 6.70514 LAYER METAL3 ;
  END Arith_OUT[8]
  PIN Arith_OUT[7] 
    ANTENNADIFFAREA 4.543 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 2.78 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 13.3718 LAYER METAL3 ;
  END Arith_OUT[7]
  PIN Arith_OUT[6] 
    ANTENNADIFFAREA 4.543 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 1.276 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 6.13756 LAYER METAL3 ;
  END Arith_OUT[6]
  PIN Arith_OUT[5] 
    ANTENNADIFFAREA 4.543 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 0.78 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.7518 LAYER METAL3 ;
  END Arith_OUT[5]
  PIN Arith_OUT[4] 
    ANTENNADIFFAREA 4.543 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 1.725 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 8.29725 LAYER METAL3 ;
  END Arith_OUT[4]
  PIN Arith_OUT[3] 
    ANTENNADIFFAREA 4.543 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 1.315 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 6.32515 LAYER METAL3 ;
  END Arith_OUT[3]
  PIN Arith_OUT[2] 
    ANTENNADIFFAREA 4.543 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 1.552 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 7.46512 LAYER METAL3 ;
  END Arith_OUT[2]
  PIN Arith_OUT[1] 
    ANTENNADIFFAREA 4.543 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 1.267 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 6.09427 LAYER METAL3 ;
  END Arith_OUT[1]
  PIN Arith_OUT[0] 
    ANTENNADIFFAREA 4.543 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 1.506 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 7.24386 LAYER METAL3 ;
  END Arith_OUT[0]
  PIN Carry_OUT 
    ANTENNADIFFAREA 4.543 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 0.257 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.23617 LAYER METAL3 ;
  END Carry_OUT
  PIN Arith_Flag 
    ANTENNADIFFAREA 4.543 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 1.652 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 7.94612 LAYER METAL3 ;
  END Arith_Flag
  PIN Logic_OUT[7] 
    ANTENNADIFFAREA 4.543 LAYER METAL5 ; 
    ANTENNAPARTIALMETALAREA 0.433 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 2.08273 LAYER METAL5 ;
  END Logic_OUT[7]
  PIN Logic_OUT[6] 
    ANTENNADIFFAREA 4.543 LAYER METAL5 ; 
    ANTENNAPARTIALMETALAREA 0.859 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 4.13179 LAYER METAL5 ;
  END Logic_OUT[6]
  PIN Logic_OUT[5] 
    ANTENNADIFFAREA 4.543 LAYER METAL5 ; 
    ANTENNAPARTIALMETALAREA 0.383 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 1.84223 LAYER METAL5 ;
  END Logic_OUT[5]
  PIN Logic_OUT[4] 
    ANTENNADIFFAREA 4.543 LAYER METAL5 ; 
    ANTENNAPARTIALMETALAREA 0.481 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 2.31361 LAYER METAL5 ;
  END Logic_OUT[4]
  PIN Logic_OUT[3] 
    ANTENNADIFFAREA 4.543 LAYER METAL5 ; 
    ANTENNAPARTIALMETALAREA 0.579 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 2.78499 LAYER METAL5 ;
  END Logic_OUT[3]
  PIN Logic_OUT[2] 
    ANTENNADIFFAREA 4.19 LAYER METAL5 ; 
    ANTENNAPARTIALMETALAREA 0.431 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 2.07311 LAYER METAL5 ;
  END Logic_OUT[2]
  PIN Logic_OUT[1] 
    ANTENNADIFFAREA 4.543 LAYER METAL5 ; 
    ANTENNAPARTIALMETALAREA 0.538 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 2.58778 LAYER METAL5 ;
  END Logic_OUT[1]
  PIN Logic_OUT[0] 
    ANTENNADIFFAREA 4.543 LAYER METAL5 ; 
    ANTENNAPARTIALMETALAREA 0.663 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 3.18903 LAYER METAL5 ;
  END Logic_OUT[0]
  PIN Logic_Flag 
    ANTENNADIFFAREA 4.543 LAYER METAL5 ; 
    ANTENNAPARTIALMETALAREA 0.581 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 2.79461 LAYER METAL5 ;
  END Logic_Flag
  PIN Shift_OUT[7] 
    ANTENNADIFFAREA 4.543 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 0.811 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.90091 LAYER METAL3 ;
  END Shift_OUT[7]
  PIN Shift_OUT[6] 
    ANTENNADIFFAREA 4.543 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 0.259 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.24579 LAYER METAL3 ;
  END Shift_OUT[6]
  PIN Shift_OUT[5] 
    ANTENNADIFFAREA 4.543 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 0.252 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.21212 LAYER METAL3 ;
  END Shift_OUT[5]
  PIN Shift_OUT[4] 
    ANTENNADIFFAREA 4.543 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 0.975 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.68975 LAYER METAL3 ;
  END Shift_OUT[4]
  PIN Shift_OUT[3] 
    ANTENNADIFFAREA 4.543 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 0.975 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.68975 LAYER METAL3 ;
  END Shift_OUT[3]
  PIN Shift_OUT[2] 
    ANTENNADIFFAREA 4.543 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 2.44 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 11.7364 LAYER METAL3 ;
  END Shift_OUT[2]
  PIN Shift_OUT[1] 
    ANTENNADIFFAREA 4.543 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 0.975 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.68975 LAYER METAL3 ;
  END Shift_OUT[1]
  PIN Shift_OUT[0] 
    ANTENNADIFFAREA 3.574 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 0.663 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.18903 LAYER METAL3 ;
  END Shift_OUT[0]
  PIN Shift_Flag 
    ANTENNADIFFAREA 4.543 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 0.483 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.32323 LAYER METAL3 ;
  END Shift_Flag
  PIN CMP_OUT[2] 
    ANTENNADIFFAREA 4.543 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 1.079 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 5.18999 LAYER METAL3 ;
  END CMP_OUT[2]
  PIN CMP_OUT[1] 
    ANTENNADIFFAREA 4.543 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 0.509 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.44829 LAYER METAL3 ;
  END CMP_OUT[1]
  PIN CMP_OUT[0] 
    ANTENNADIFFAREA 4.543 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 0.401 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.92881 LAYER METAL3 ;
  END CMP_OUT[0]
  PIN CMP_Flag 
    ANTENNADIFFAREA 4.543 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 2.369 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 11.3949 LAYER METAL3 ;
  END CMP_Flag
END ALU_TOP

END LIBRARY
